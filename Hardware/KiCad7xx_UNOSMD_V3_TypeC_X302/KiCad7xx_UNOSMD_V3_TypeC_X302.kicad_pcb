# Repository hirotaka42/KiCad_UnoTypeC

## KiCad design Hardware/KiCad7xx_UNOSMD_V3_TypeC_X302/KiCad7xx_UNOSMD_V3_TypeC_X302.kicad_pcb

Parts:
C1, C2, C4, C5, C6, C7: 100n; C0603-ROUND
C3, C8: 1u; C0603-ROUND
C10: 100nF; C0603-ROUND
D1: M7; SMB
D2, D3, D4: CD1206-S01575; MINIMELF
F1: MF-MSMF050-2 500mA; L1812
FD1, FD2, FD3: FIDUCIAL-1.5MM; FD-1-1.5
GROUND0: SJ
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO14580
ICSP0, ICSP1: 3x2 M; 2X03
J1: -; 1X14-CUSTOM
J2: PINHD-1X18; 1X18-CUSTOM
J3: USB_C_Receptacle_USB2.0JAE_DX07S016JA1R1500; USB_C_Receptacle_JAE_DX07S016JA1R1500
JP2: 2x2 M-NM; 2X02
L1: BLM21; 0805
L2: 10uH; 0805
L3: YELLOW; CHIP-LED0805
ON1: GREEN; CHIP-LED0805
ORIGIN0: TP_SP; TP-SP
PC1, PC2: 47u; PANASONIC_D
R1, R2: 1M; R0603-ROUND
R3, R4: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RESET0: TS42
RESET-EN0: SJ
RN1: 10K; CAY16
RN2, RN4: 1K; CAY16
RN3: 22R; CAY16
RX0: YELLOW; CHIP-LED0805
T1: FDN340P; SOT-23
TP_5V1: TP_SP; TP-SP
TP_DTR0: TP_SP; TP-SP
TP_LCMD1: TP_SP; TP-SP
TP_LL1: TP_SP; TP-SP
TP_MISO2: TP_SP; TP-SP
TP_MOSI2: TP_SP; TP-SP
TP_ONL1: TP_SP; TP-SP
TP_RESET2: TP_SP; TP-SP
TP_RX0: TP_SP; TP-SP
TP_RXL0: TP_SP; TP-SP
TP_SCK2: TP_SP; TP-SP
TP_TX0: TP_SP; TP-SP
TP_TXL0: TP_SP; TP-SP
TP_USBVCC0: TP_SP; TP-SP
TP_USH0: TP_SP; TP-SP
TP_VUCAP0: TP_SP; TP-SP
TX0: YELLOW; CHIP-LED0805
U1: MC33269ST; SOT223
U2: LP2985-XXDBVR; SOT23-DBV
U3: ATMEGA16U2; ATMEL_QFN32
U4: ATMEGAXX8-MUR; TQFP-32_7x7mm_P0.8mm
U5: LMV358?MM; MSOP08
U6: BCM857BS; SOT65P210X110-6N
X1: POWERSUPPLY_DC21MMX; POWERSUPPLY_DC-21MM
Y1, Y2: RESONATORMU; RESONATOR
Z1, Z2: VARISTORCN0603; CT_CN0603

Connections:
5-GND: RESET0.5 (5-GND)
+3V3: C3.2, J1.4, U2.5 (OUT)
+5V: C1.2, C2.2, C6.2, C7.1, D2.C, D3.C, ICSP0.2, ICSP1.2, J1.2, J1.5, L2.1, PC2.+, RN1.3 (1), RN1.5 (2), RN2.2 (1), RN2.3 (1), RN4.3 (1), RN4.4 (1), T1.2 (S), TP_5V1.X (TESTP), U1.2 (OUT@1), U1.4 (OUT), U2.1 (IN), U2.3 (ON/~OFF), U3.4 (VCC), U3.32 (AVCC), U4.4 (VCC@1), U4.6 (VCC@2), U5.8 (V+), U6.4
/A0: J1.9, U4.23 (PC0(ADC0))
/A1: J1.10, U4.24 (PC1(ADC1))
/A2: J1.11, U4.25 (PC2(ADC2))
/A3: J1.12, U4.26 (PC3(ADC3))
/A4/SDA: J1.13, J2.17, U4.27 (PC4(ADC4/SDA))
/A5/SCL: J1.14, J2.18, U4.28 (PC5(ADC5/SCL))
/AREF: C4.2, J2.16, U4.20 (AREF)
/D+: J3.A6 (D+), J3.B6 (D+), RN3.5 (2), Z1.1
/D-: J3.A7 (D-), J3.B7 (D-), RN3.8 (2), Z2.1
/DTR: C5.1, RN2.4 (1), TP_DTR0.X (TESTP), U3.13 ((CTS/HWB/AIN6/TO/INT7)PD7)
/IO0: J2.1, RN4.2 (1), U4.30 (PD0(RXD))
/IO1: J2.2, RN4.1, U4.31 (PD1(TXD))
/IO2: J2.3, U4.32 (PD2(INT0))
/IO3: J2.4, U4.1 (PD3(INT1))
/IO4: J2.5, U4.2 (PD4(XCK/T0))
/IO5: J2.6, U4.9 (PD5(T1))
/IO6: J2.7, U4.10 (PD6(AIN0))
/IO7: J2.8, U4.11 (PD7(AIN1))
/IO8: J2.9, U4.12 (PB0(ICP))
/IO9: J2.10, U4.13 (PB1(OC1A))
/L13: RN2.8 (2), TP_LCMD1.X (TESTP), U5.6 (-IN), U5.7 (OUT)
/M8RXD: RN4.7 (2), TP_RX0.X (TESTP), U3.9 ((TXD1/INT3)PD3)
/M8TXD: RN4.8 (2), TP_TX0.X (TESTP), U3.8 ((RXD1/AIN1/INT2)PD2)
/MISO: ICSP0.1, J2.13, U4.16 (PB4(MISO))
/MISO2: ICSP1.1, TP_MISO2.X (TESTP), U3.17 ((PD0/MISO/PCINT3)PB3)
/MOSI: ICSP0.4, J2.12, U4.15 (PB3(MOSI/OC2))
/MOSI2: ICSP1.4, TP_MOSI2.X (TESTP), U3.16 ((PDI/MOSI/PCINT2)PB2)
/PB4: JP2.1, U3.18 ((T1/PCINT4)PB4)
/PB5: JP2.3, U3.19 ((PCINT5)PB5)
/PB6: JP2.2, U3.20 ((PCINT6)PB6)
/PB7: JP2.4, U3.21 ((PCINT7/OC0A/OC1C)PB7)
/PWRIN: D1.A, X1.2
/RD+: RN3.4 (1), U3.29 (D+)
/RD-: RN3.1, U3.30 (D-)
/RESET: C5.2, D2.A, ICSP0.5, J1.3, RESET0.3, RESET0.4, RESET-EN0.1, RESET-EN0.2, RN1.4 (1), U4.29 (PC6(/RESET))
/RESET2: D3.A, ICSP1.5, RN1.6 (2), TP_RESET2.X (TESTP), U3.24 (RESET(PC1/DW))
/RXLED: RX0.C, U3.10 ((INT5/AIN3)PD4)
/SCK: ICSP0.3, J2.14, U4.17 (PB5(SCK)), U5.5 (+IN)
/SCK2: ICSP1.3, TP_SCK2.X (TESTP), U3.15 ((SCLK/PCINT1)PB1)
/SS: J2.11, U4.14 (PB2(SS/OC1B))
/TP_VUCAP: C8.1, TP_VUCAP0.X (TESTP), U3.27 (UCAP)
/TXLED: TX0.C, U3.11 ((XCK/AIN4/PCINT12)PD5)
/UGND: C8.2, GROUND0.2, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), L1.1, U3.28 (UGND)
/USBVCC: F1.1, T1.1 (D), TP_USBVCC0.X (TESTP), U3.31 (UVCC), U6.1
/USHIELD: J3.S1 (SHIELD), L1.2, TP_USH0.X (TESTP), Z1.2, Z2.2
/XT1: R1.1, U3.1 (XTAL1), Y1.3
/XT2: R1.2, U3.2 (XTAL2(PC0)), Y1.1
/XTAL1: R2.1, U4.7 (PB6(XTAL1/TOSC1)), Y2.3
/XTAL2: R2.2, U4.8 (PB7(XTAL2/TOSC2)), Y2.1
/XUSB: F1.2, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
GND: C1.1, C2.1, C3.1, C4.1, C6.1, C7.2, C10.2, GROUND0.1, ICSP0.6, ICSP1.6, J1.6, J1.7, J2.15, L3.C, ON1.C, PC1.-, PC2.-, R3.2, R4.2, R5.2, RESET0.1, RESET0.2, RN1.1, RN2.5 (2), U1.1 (GND/ADJ), U2.2 (GND), U3.3 (GND), U3.EXP (PAD), U4.3 (GND@1), U4.5 (GND@2), U4.21 (AGND), U5.4 (V-), X1.1, X1.3, Y1.2, Y2.2
unnamed: D4.A, J1.8
unnamed: J3.A5 (CC1), R3.1
unnamed: J3.B5 (CC2), R4.1
unnamed: RN1.8 (2), U6.2, U6.5, U6.6
unnamed: RN2.7 (2), RX0.A, TP_RXL0.X (TESTP)
unnamed: RN2.6 (2), TP_TXL0.X (TESTP), TX0.A
unnamed: ON1.A, RN4.5 (2), RN4.6 (2), TP_ONL1.X (TESTP)
unnamed: R5.1, T1.3 (G), U6.3
unnamed: L3.A, RN2.1, TP_LL1.X
unnamed: C10.1, L2.2, U4.18 (AVCC)
VIN: D1.C, D4.C, PC1.+, U1.3 (IN)

Notes on the sheet:
BCM857BS
USB boot En
理想ダイオード
Power Block
Power LED
D13Pin LED
LMV358IDGKR
3V3

Board: 2 copper layers, 68.6 x 53.3 mm, 75 parts (1 on the bottom side), 64 nets.

## KiCad design Hardware/KiCad7xx_UNO-TH_Rev3e/KiCad7xx_UNO-TH_Rev3e.kicad_pcb

Parts:
AD0: 6x1F-H8.5; 1X06
C1, C2, C4, C5, C6, C7, C10: 100n; C0603-ROUND
C3, C8: 1u; C0603-ROUND
C9, C11: 22p; C0603-ROUND
D1: M7; SMB
D2, D3: CD1206-S01575; MINIMELF
F1: MF-MSMF050-2 500mA; L1812
FD1, FD2, FD3: FIDUCIALMOUNT; FIDUCIA-MOUNT
GND_TP0, GND_TP1: TP_SP; TP-SP
GROUND0: SJ
ICSP0, ICSP1: 3x2 M; 2X03
IOH0: 10x1F-H8.5; 1X10
IOL0: 8x1F-H8.5; 1X08
JP2: 2x2 M - NM; 2X02
L0: YELLOW; CHIP-LED0805
L1: BLM21; 0805
L2: 10uH; 0805
ON0: GREEN; CHIP-LED0805
ORIGIN0: TP_SP; TP-SP
PC1, PC2: 47u; PANASONIC_D
POWER0: 8x1F-H8.5; 1X08
R1, R2: 1M; R0603-ROUND
RESET0: TS42
RESET-EN0: SJ
RN1: 10K; CAY16
RN2, RN4: 1K; CAY16
RN3: 22R; CAY16
RX0: YELLOW; CHIP-LED0805
T1: FDN340P; SOT-23
TP_0, TP_1, TP_2, TP_3, TP_3V3, TP_4, TP_5, TP_5V0, TP_5V1, TP_6, TP_7, TP_8, TP_9, TP_10, TP_11, TP_12, TP_13: TP_SP; TP-SP
TP_A0, TP_A1, TP_A2, TP_A3, TP_A4, TP_A5: TP_SP; TP-SP
TP_AREF0: TP_SP; TP-SP
TP_CMP0: TP_SP; TP-SP
TP_D+0: TP_SP; TP-SP
TP_D-0: TP_SP; TP-SP
TP_DTR0: TP_SP; TP-SP
TP_GATE0: TP_SP; TP-SP
TP_LCMD0: TP_SP; TP-SP
TP_LL0: TP_SP; TP-SP
TP_MISO2: TP_SP; TP-SP
TP_MOSI2: TP_SP; TP-SP
TP_ONL0: TP_SP; TP-SP
TP_PB4, TP_PB5, TP_PB6, TP_PB7: TP_SP; TP-SP
TP_PWRIN0: TP_SP; TP-SP
TP_RESET0, TP_RESET2: TP_SP; TP-SP
TP_RX0: TP_SP; TP-SP
TP_RXL0: TP_SP; TP-SP
TP_SCK2: TP_SP; TP-SP
TP_SCL0: TP_SP; TP-SP
TP_SDA0: TP_SP; TP-SP
TP_TX0: TP_SP; TP-SP
TP_TXL0: TP_SP; TP-SP
TP_UGND0: TP_SP; TP-SP
TP_USBVCC0: TP_SP; TP-SP
TP_USH0: TP_SP; TP-SP
TP_VIN0: TP_SP; TP-SP
TP_VUCAP0: TP_SP; TP-SP
TP_XT1, TP_XT2, TP_XT3, TP_XT4: TP_SP; TP-SP
TP_XUSB0: TP_SP; TP-SP
TX0: YELLOW; CHIP-LED0805
U1: MC33269ST; SOT223
U2: LP2985-XXDBVR; SOT23-DBV
U3: ATMEGA16U2-MU; MLF32
U5: LMV358?MM; MSOP08
X1: POWERSUPPLY_DC21MMX; POWERSUPPLY_DC-21MM
X2: USB-B_TH; PN61729
Y1: 16MHz; QS
Y2: RESONATORMU; RESONATOR
Z1, Z2: VARISTORCN0603; CT_CN0603
ZU4: ATMEGA328P-PU; DIL28-3

Connections:
5-GND: RESET0.5 (5-GND)
+3V3: C3.2, POWER0.4, TP_3V3.X, U2.5 (OUT), U5.2 (-IN)
+5V: C1.2, C2.2, C6.2, C7.1, D2.C, D3.C, ICSP0.2, ICSP1.2, L2.1, PC2.+, POWER0.2, POWER0.5, RN1.3 (1), RN1.5 (2), RN2.2 (1), RN2.3 (1), RN4.3 (1), RN4.4 (1), T1.2 (S), TP_5V0.X, TP_5V1.X, U1.2 (OUT@1), U1.4 (OUT), U2.1 (IN), U2.3 (ON/~OFF), U3.4 (VCC), U3.32 (AVCC), U5.8 (V+), ZU4.7 (VCC)
AD0: AD0.1, TP_A0.X, ZU4.23 ((ADC0)PC0))
AD1: AD0.2, TP_A1.X, ZU4.24 ((ADC1)PC1)
AD2: AD0.3, TP_A2.X, ZU4.25 ((ADC2)PC2)
AD3: AD0.4, TP_A3.X, ZU4.26 ((ADC3)PC3)
AD4/SDA: AD0.5, IOH0.9, TP_A4.X, TP_SDA0.X, ZU4.27 ((ADC4)PC4)
AD5/SCL: AD0.6, IOH0.10, TP_A5.X, TP_SCL0.X, ZU4.28 ((ADC5)PC5)
AREF: C4.2, IOH0.8, TP_AREF0.X, ZU4.21 (AREF)
AVCC: C10.2, L2.2, ZU4.20 (AVCC)
CMP: RN1.1, RN1.2 (1), TP_CMP0.X, U5.3 (+IN)
D+: RN3.5 (2), TP_D+0.X, X2.3, Z1.1
D-: RN3.8 (2), TP_D-0.X, X2.2, Z2.1
DTR: C5.1, RN2.4 (1), TP_DTR0.X, U3.13 ((CTS/HWB/AIN6/TO/INT7)PD7)
GATE_CMD: T1.3 (G), TP_GATE0.X, U5.1 (OUT)
GND: C1.1, C2.1, C3.1, C4.1, C6.1, C7.2, C9.2, C10.1, C11.2, GND_TP0.X, GND_TP1.X, GROUND0.1, ICSP0.6, ICSP1.6, IOH0.7, L0.C, ON0.C, PC1.-, PC2.-, POWER0.6, POWER0.7, RESET0.1, RESET0.2, RN1.7 (2), RN2.5 (2), U1.1 (GND/ADJ), U2.2 (GND), U3.3 (GND), U3.33 (PAD), U5.4 (V-), X1.1, X1.3, Y2.2, ZU4.8 (GND), ZU4.22 (AGND)
IO0: IOL0.1, RN4.2 (1), TP_0.X, ZU4.2 ((RXD)PD0)
IO1: IOL0.2, RN4.1, TP_1.X, ZU4.3 ((TXD)PD1)
IO2: IOL0.3, TP_2.X, ZU4.4 ((INT0)PD2)
IO3: IOL0.4, TP_3.X, ZU4.5 ((INT1)PD3)
IO4: IOL0.5, TP_4.X, ZU4.6 ((T0)PD4)
IO5: IOL0.6, TP_5.X, ZU4.11 ((T1)PD5)
IO6: IOL0.7, TP_6.X, ZU4.12 ((AIN0)PD6)
IO7: IOL0.8, TP_7.X, ZU4.13 ((AIN1)PD7)
IO8: IOH0.1, TP_8.X, ZU4.14 ((ICP)PB0)
IO9: IOH0.2, TP_9.X, ZU4.15 ((OC1)PB1)
L13: RN2.8 (2), TP_LCMD0.X, U5.6 (-IN), U5.7 (OUT)
M8RXD: RN4.7 (2), TP_RX0.X, U3.9 ((TXD1/INT3)PD3)
M8TXD: RN4.8 (2), TP_TX0.X, U3.8 ((RXD1/AIN1/INT2)PD2)
MISO: ICSP0.1, IOH0.5, TP_12.X, ZU4.18 ((MISO)PB4)
MISO2: ICSP1.1, TP_MISO2.X, U3.17 ((PD0/MISO/PCINT3)PB3)
MOSI: ICSP0.4, IOH0.4, TP_11.X, ZU4.17 ((MOSI)PB3)
MOSI2: ICSP1.4, TP_MOSI2.X, U3.16 ((PDI/MOSI/PCINT2)PB2)
unnamed: L0.A, RN2.1, TP_LL0.X
unnamed: ON0.A, RN4.5 (2), RN4.6 (2), TP_ONL0.X
unnamed: RN2.7 (2), RX0.A, TP_RXL0.X
unnamed: RN2.6 (2), TP_TXL0.X, TX0.A
PB4: JP2.1, TP_PB4.X, U3.18 ((T1/PCINT4)PB4)
PB5: JP2.3, TP_PB5.X, U3.19 ((PCINT5)PB5)
PB6: JP2.2, TP_PB6.X, U3.20 ((PCINT6)PB6)
PB7: JP2.4, TP_PB7.X, U3.21 ((PCINT7/OC0A/OC1C)PB7)
PWRIN: D1.A, TP_PWRIN0.X, X1.2
RD+: RN3.4 (1), U3.29 (D+)
RD-: RN3.1, U3.30 (D-)
RESET: C5.2, D2.A, ICSP0.5, POWER0.3, RESET0.3, RESET0.4, RESET-EN0.1, RESET-EN0.2, RN1.4 (1), TP_RESET0.X, ZU4.1 (RESET)
RESET2: D3.A, ICSP1.5, RN1.6 (2), TP_RESET2.X, U3.24 (RESET(PC1/DW))
RXLED: RX0.C, U3.10 ((INT5/AIN3)PD4)
SCK: ICSP0.3, IOH0.6, TP_13.X, U5.5 (+IN), ZU4.19 ((SCK)PB5)
SCK2: ICSP1.3, TP_SCK2.X, U3.15 ((SCLK/PCINT1)PB1)
SS: IOH0.3, TP_10.X, ZU4.16 ((SS)PB2)
TP_VUCAP: C8.1, TP_VUCAP0.X, U3.27 (UCAP)
TXLED: TX0.C, U3.11 ((XCK/AIN4/PCINT12)PD5)
UGND: C8.2, GROUND0.2, L1.1, TP_UGND0.X, U3.28 (UGND), X2.4
USBVCC: F1.1, T1.1 (D), TP_USBVCC0.X, U3.31 (UVCC)
USHIELD: L1.2, TP_USH0.X, X2.P$1, X2.P$2, Z1.2, Z2.2
VIN: D1.C, PC1.+, POWER0.8, RN1.8 (2), TP_VIN0.X, U1.3 (IN)
XT1: C9.1, R1.1, TP_XT3.X, U3.1 (XTAL1), Y1.2
XT2: C11.1, R1.2, TP_XT4.X, U3.2 (XTAL2(PC0)), Y1.1
XTAL1: R2.1, TP_XT1.X, Y2.3, ZU4.9 (XTAL1)
XTAL2: R2.2, TP_XT2.X, Y2.1, ZU4.10 (XTAL2)
XUSB: F1.2, TP_XUSB0.X, X2.1

Notes on the sheet:
SCL
Arduino(TM) UNO Rev3
USB boot En
SDA

Board: 2 copper layers, 68.6 x 53.3 mm, 120 parts (1 on the bottom side), 61 nets.

Other parts of the board:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
FRAME1: DNP; FRAME

## KiCad design Hardware/Make/KiCad7xx_UnoTypeC.kicad_pcb

Parts:
1: POWERSUPPLY_DC21MMX; POWERSUPPLY_DC-21MM
2: ATMEGA16U2-MU; MLF32
C1, C2, C3, C7, C9, C10, C11: 100nF; C0603-ROUND
C4, C8: 1uF; C0603-ROUND
C5, C6: EEE1EA470WP; PANASONIC_D
D1, D5: CD1206-S01575(BOURNS); MINIMELF
D2: YELLOW/13D; CHIP-LED0805
D3: GREEN/ON; CHIP-LED0805
D4: M7; SMB
D6: YELLO/TX; CHIP-LED0805
D7: YELLO/RX; CHIP-LED0805
F1: MF-MSMF050-2 500mA; L1812
IC1: AP7366-33W5-7/600mA(Diodes); SOT23-DBV
IC2: ATMEGA328P-PU; DIL28-3
IC3: NCP1117ST50T3G; SOT223
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
JP1: GROUND; SJ
JP2: RESET-EN; SJ
L1: 10uH_BLM18PG471SN1D(Murata); 0805
L2: BLM21PG221SN1D(Murata)/0805; 0805
Q1: FDN340P; SOT-23
R1, R2: 1M; C0603-ROUND
RN1: 22R; CAY16
RN2: 10K; CAY16
RN3: 5.1K; CAY16
RN4, RN5: 1K; CAY16
RV1, RV2: CG0603MLC-05E(Bourns); CT_CN0603
SW1: RESET; TS42
U1: LMV358IDGKR(Texas); MSOP08; PARTREV X
UnoJP1: A0011; UnoRev3_A0011
Y1, Y2: CSTNE16M0V530000R0; RESONATOR

Connections:
+5V: 2.4 (VCC), 2.32 (AVCC), C2.1, C3.2, C6.+, C7.1, C9.1, D1.C, D5.C, IC1.1 (IN), IC1.3 (ON/~OFF), IC2.7 (VCC), IC3.2 (OUT@1), IC3.4 (OUT), L1.2, Q1.2 (S), RN2.3 (1), RN2.5 (2), RN4.3 (1), RN4.4 (1), RN5.2 (1), RN5.3 (1), U1.8 (VCC+), UnoJP1.5V_1 (5V), UnoJP1.5V_2 (5V_2P), UnoJP1.5V_3 (5V_2U), UnoJP1.IOREF
/AREF: C11.1, IC2.21 (AREF), UnoJP1.AREF
/D+: J1.A6 (D+), J1.B6 (D+), RN1.5 (2), RV2.1
/D-: J1.A7 (D-), J1.B7 (D-), RN1.8 (2), RV1.1
/GATE_CMD: Q1.1 (G), U1.1
/M8RXD: 2.9 ((TXD1/INT3)PD3), RN4.7 (2)
/M8TXD: 2.8 ((RXD1/AIN1/INT2)PD2), RN5.8 (2)
/PB0(ICP): IC2.14 ((ICP)PB0), UnoJP1.D8
/PB1(OC1): IC2.15 ((OC1)PB1), UnoJP1.D9
/PB1(SCK2): 2.15 ((SCLK/PCINT1)PB1), UnoJP1.3U (PB1(SCLK))
/PB2(MOSI2): 2.16 ((PDI/MOSI/PCINT2)PB2), UnoJP1.4U ((MOSI)PB2)
/PB2(SS): IC2.16 ((SS)PB2), UnoJP1.D10
/PB3(MISO2): 2.17 ((PD0/MISO/PCINT3)PB3), UnoJP1.1U (PB3(MISO))
/PB3(MOSI): IC2.17 ((MOSI)PB3), UnoJP1.4P ((MOSI)PB3), UnoJP1.D11
/PB4(MISO): IC2.18 ((MISO)PB4), UnoJP1.1P (PB4(MISO)), UnoJP1.D12
/PB5(SCK): IC2.19 ((SCK)PB5), U1.5, UnoJP1.3P (PB5(SCK)), UnoJP1.D13
/PC0: IC2.23 ((ADC0)PC0)), UnoJP1.A0
/PC1: IC2.24 ((ADC1)PC1), UnoJP1.A1
/PC2: IC2.25 ((ADC2)PC2), UnoJP1.A2
/PC3: IC2.26 ((ADC3)PC3), UnoJP1.A3
/PC4(SDA): IC2.27 ((ADC4)PC4), UnoJP1.A4, UnoJP1.A4(SDA) (AD4/SDA)
/PC5(SCL): IC2.28 ((ADC5)PC5), UnoJP1.A5, UnoJP1.A5(SCL) (AD5/SCL)
/PD0(RX): IC2.2 ((RXD)PD0), RN4.2 (1), UnoJP1.D0 (D0/RX)
/PD1(TX): IC2.3 ((TXD)PD1), RN5.1, UnoJP1.D1 (D1/TX)
/PWRIN: 1.2, D4.A
/RD+: 2.29 (D+), RN1.4 (1)
/RD-: 2.30 (D-), RN1.1
/RESET: D1.A, IC2.1 (RESET), JP2.2 (B), RN2.4 (1), SW1.3, SW1.4, UnoJP1.5P (RST), UnoJP1.RST
/UGND: 2.28 (UGND), C8.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), JP1.2 (B), L2.2
/USBVCC: 2.31 (UVCC), F1.2, Q1.3 (D)
/VIN: C5.+, D4.C, IC3.3 (IN), RN2.8 (2), UnoJP1.VIN
/Vin/2: RN2.1, RN2.2 (1), U1.3
GND: 1.1, 1.3, 2.3 (GND), 2.33 (PAD), C1.2, C2.2, C3.1, C4.2, C5.-, C6.-, C7.2, C9.2, C11.2, D2.C, D3.C, IC1.2 (GND), IC2.8 (GND), IC2.22 (AGND), IC3.1 (GND/ADJ), JP1.1 (A), RN2.7 (2), RN3.1, RN3.3 (1), RN5.5 (2), SW1.1, SW1.2, U1.4 (GND), UnoJP1.GND_1, UnoJP1.GND_2, UnoJP1.GND_3, UnoJP1.GND_4 (GND_6P), UnoJP1.GND_5 (GND_6U), Y1.2, Y2.2
unnamed: 2.13 ((CTS/HWB/AIN6/TO/INT7)PD7), C10.1, RN5.4 (1)
unnamed: 2.10 ((INT5/AIN3)PD4), D7.C
unnamed: 2.19 ((PCINT5)PB5), UnoJP1.3 (PB5(PCINT5))
unnamed: 2.20 ((PCINT6)PB6), UnoJP1.2 ((PCINT6)PB6)
unnamed: 2.21 ((PCINT7/OC0A/OC1C)PB7), UnoJP1.4 ((PCINT7)PB7)
unnamed: 2.18 ((T1/PCINT4)PB4), UnoJP1.1 (PB4(PCINT4))
unnamed: 2.11 ((XCK/AIN4/PCINT12)PD5), D6.C
unnamed: 2.24 (RESET(PC1/DW)), D5.A, RN2.6 (2), UnoJP1.5U (RESET(PC1/DW))
unnamed: 2.27 (UCAP), C8.1
unnamed: 2.1 (XTAL1), R2.2, Y2.3
unnamed: 2.2 (XTAL2(PC0)), R2.1, Y2.1
unnamed: D2.A, RN4.1
unnamed: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: IC2.12 ((AIN0)PD6), UnoJP1.D6 (D6#)
unnamed: IC2.13 ((AIN1)PD7), UnoJP1.D7
unnamed: IC2.4 ((INT0)PD2), UnoJP1.D2
unnamed: IC2.5 ((INT1)PD3), UnoJP1.D3 (D3#)
unnamed: IC2.6 ((T0)PD4), UnoJP1.D4
unnamed: IC2.11 ((T1)PD5), UnoJP1.D5 (D5#)
unnamed: C1.1, IC2.20 (AVCC), L1.1
unnamed: IC2.9 (XTAL1), R1.2, Y1.3
unnamed: IC2.10 (XTAL2), R1.1, Y1.1
unnamed: J1.A5 (CC1), RN3.6 (2)
unnamed: J1.B5 (CC2), RN3.8 (2)
unnamed: J1.S1 (SHIELD), L2.1, RV1.2, RV2.2
unnamed: C10.2, JP2.1 (A)
unnamed: RN4.8 (2), U1.6, U1.7
unnamed: D3.A, RN4.5 (2), RN4.6 (2)
unnamed: D7.A, RN5.7 (2)
unnamed: D6.A, RN5.6 (2)

Notes on the sheet:
POWER
SOT-25 / 23-5L

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
Board: 2 copper layers, 44 parts (1 on the bottom side), 65 nets, no tracks yet.

## Commit log

2023-03-04 feat: first commit
2023-03-04 add: .gitignore の追加
2023-03-04 feat: UnoTypeCプロジェクトファイルの新規作成
2023-03-04 add: TypeCとリゾネータ部品データの追加
2023-03-06 feat: KiCad7xx_UnoTypeCにて既存のUnoRev3回路図をType-Cに変更
2023-03-06 add: PDF-SCHにKiCad7xx_UnoTypeCの回路図を出力
2023-03-06 fix: HRO_TYPE-Cシンボルにて誤ったシンボルが選択されていた為、修正
2023-03-06 feat: PCBにTypeCの配線を追加
2023-03-07 feat: Gerberとシルクデザインの作成
2023-03-07 add: UNO-Rev3_SMDをKiCadプロジェクトに変換
2023-03-07 feat: UnoRev3SMDの作業フォルダの作成
2023-03-08 feat: 取り付け穴が消えてしまう為,新たにM3_IOS14580を追加
2023-03-08 feat: Type-Cコネクタの回路を追加
2023-03-08 feat: 回路図を見やすくするために変更
2023-03-08 feat: DCアダプタのシンボルを変更するに伴い,フットプリントの編集
2023-03-08 feat: 変更した部品のフットプリントを再度配線
2023-03-09 feat: 電源回路を見直しダイオードSS54B(FOSAN)の追加
2023-03-10 feat: UnoTypeC_SMD Rev1Cのガーバファイルを作成
2023-06-02 Add .gitignore
2023-06-02 Add DIP-Pin(UNO-TH-Rev3e)
2023-06-02 Add SMD-Pin(UNO-SMD-Rev3)
2023-06-02 Add .DS_Store Setting to .gitignore
2023-06-02 Remove ignored files
2023-06-02 Add:Converted for KiCad projects added.
2023-06-02 Add:Added ArduinoSMD converted for KiCad project.
2023-06-03 Add:Add converted to KiCad project
2023-06-03 Add:TypeC was added to the connector in the schematic.
2023-06-03 update:update .gitignore
2023-06-03 update: 3rdpartyのファイルのみをgit管理対象から除外
2023-06-03 Add:TypeC connector was added to the board data.
2023-06-04 Add:New Project X301 added.
2023-06-04 Add: 回路ブロックを編集しやすいように分割
2023-06-04 Add: X301の回路図に理想ダイオード回路を追加しました
2023-06-04 Add:部品点数を減らすために16U2のクリスタルを変更
2023-06-04 Add: VIN電源にダイオードを追加
2023-06-04 Add:X301の基板データに回路図の変更を追加
2023-06-04 Add: X302プロジェクトを作成
2023-06-04 Add:MURからAUパッケージへ基板データを変更
2023-06-04 Add:基板レイアウトを微修正
2023-06-04 Add:基板デザインに'UNO-C X302'文字の追加
